<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>datafile</value></param>
<param><key>value</key><value>prefixdata + datetime.now().strftime("%Y.%m.%d_%H.%M.%S") + ".log"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fftfile</value></param>
<param><key>value</key><value>prefixfft + datetime.now().strftime("%Y.%m.%d_%H.%M.%S") + ".log"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fftsize</value></param>
<param><key>value</key><value>pow(2,11)</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>intamp</value></param>
<param><key>comment</key><value>To inject artificial
SETI Signal</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>20e-6</value></param>
<param><key>label</key><value></value></param>
<param><key>max</key><value>0.001</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>prefixdata</value></param>
<param><key>value</key><value>"/media/michel/SETI/data_"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>prefixfft</value></param>
<param><key>value</key><value>"/media/michel/SETI/fft_"</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>record</value></param>
<param><key>block_id</key><value>blocks_threshold_ff_0</value></param>
<param><key>comment</key><value>Copies threshold value
to variable record</value></param>
<param><key>function_name</key><value>last_state</value></param>
<param><key>poll_rate</key><value>5</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>10e6</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>intamp</value></param>
<param><key>comment</key><value>To inject artificial signal for testing</value></param>
<param><key>freq</key><value>1421e6</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>blks2_valve</key>
<param><key>id</key><value>blks2_valve_0</value></param>
<param><key>comment</key><value>Note threshold value
is inverted here</value></param>
<param><key>open</key><value>1-record</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>datafile</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0</value></param>
<param><key>file</key><value>fftfile</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vlen</key><value>fftsize</value></param>
</block>
<block>
<key>blocks_float_to_char</key>
<param><key>id</key><value>blocks_float_to_char_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_head</key>
<param><key>id</key><value>blocks_head_0</value></param>
<param><key>num_items</key><value>10000*fftsize</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_keep_m_in_n</key>
<param><key>id</key><value>blocks_keep_m_in_n_0</value></param>
<param><key>m</key><value>fftsize</value></param>
<param><key>n</key><value>100*fftsize</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_items</key><value>fftsize</value></param>
</block>
<block>
<key>blocks_threshold_ff</key>
<param><key>id</key><value>blocks_threshold_ff_0</value></param>
<param><key>high</key><value>-78</value></param>
<param><key>init</key><value>0</value></param>
<param><key>low</key><value>-1000</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>fftsize</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_0</value></param>
<param><key>comment</key><value>HPF for subtracting 
DC peak
Stop band 1e3
Pass band 5e4
Attn 10dB</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>[-0.0010990326991304755, -0.0011334356386214495, -0.0011985328746959567, -0.001295603928156197, -0.0014257250586524606, -0.0015897577395662665, -0.0017883378313854337, -0.002021867549046874, -0.002290506847202778, -0.0025941694620996714, -0.0029325177893042564, -0.003304962767288089, -0.0037106613162904978, -0.004148522391915321, -0.0046172053553164005, -0.005115131381899118, -0.005640486720949411, -0.006191234104335308, -0.006765123922377825, -0.007359706796705723, -0.007972347550094128, -0.00860024243593216, -0.00924043171107769, -0.009889830835163593, -0.010545231401920319, -0.011203338392078876, -0.011860785074532032, -0.012514152564108372, -0.01316000148653984, -0.013794880360364914, -0.01441536657512188, -0.015018078498542309, -0.015599698759615421, -0.016157003119587898, -0.016686875373125076, -0.01718633621931076, -0.017652561888098717, -0.01808289811015129, -0.0184748824685812, -0.01882627233862877, -0.019135037437081337, -0.01939939707517624, -0.019617818295955658, -0.019789034500718117, -0.019912049174308777, -0.019986147060990334, 1.9810783863067627, -0.019986147060990334, -0.019912049174308777, -0.019789034500718117, -0.019617818295955658, -0.01939939707517624, -0.019135037437081337, -0.01882627233862877, -0.0184748824685812, -0.01808289811015129, -0.017652561888098717, -0.01718633621931076, -0.016686875373125076, -0.016157003119587898, -0.015599698759615421, -0.015018078498542309, -0.01441536657512188, -0.013794880360364914, -0.01316000148653984, -0.012514152564108372, -0.011860785074532032, -0.011203338392078876, -0.010545231401920319, -0.009889830835163593, -0.00924043171107769, -0.00860024243593216, -0.007972347550094128, -0.007359706796705723, -0.006765123922377825, -0.006191234104335308, -0.005640486720949411, -0.005115131381899118, -0.0046172053553164005, -0.004148522391915321, -0.0037106613162904978, -0.003304962767288089, -0.0029325177893042564, -0.0025941694620996714, -0.002290506847202778, -0.002021867549046874, -0.0017883378313854337, -0.0015897577395662665, -0.0014257250586524606, -0.001295603928156197, -0.0011985328746959567, -0.0011334356386214495, -0.0010990326991304755]</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_1</value></param>
<param><key>comment</key><value>LPF for subtracting end of band</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>[0.07469794899225235, 1.8506040573120117, 0.07469794899225235]</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from datetime import datetime</value></param>
</block>
<block>
<key>logpwrfft_x</key>
<param><key>id</key><value>logpwrfft_x_0</value></param>
<param><key>avg_alpha</key><value>0.01</value></param>
<param><key>average</key><value>True</value></param>
<param><key>fft_size</key><value>fftsize</value></param>
<param><key>frame_rate</key><value>30</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ref_scale</key><value>2</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>bb_gain0</key><value>10</value></param>
<param><key>bw0</key><value>15e6</value></param>
<param><key>dc_offset_mode0</key><value>2</value></param>
<param><key>freq0</key><value>1420e6</value></param>
<param><key>gain_mode0</key><value>True</value></param>
<param><key>if_gain0</key><value>10</value></param>
<param><key>iq_balance_mode0</key><value>2</value></param>
<param><key>gain0</key><value>10</value></param>
<param><key>args</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>avg_alpha</key><value>0.01</value></param>
<param><key>average</key><value>True</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_rate</key><value>10</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>win</key><value>window.blackmanharris</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>y_per_div</key><value>10</value></param>
</block>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blks2_valve_0</source_block_id><sink_block_id>blocks_head_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>blks2_valve_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>logpwrfft_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_char_0</source_block_id><sink_block_id>blocks_keep_m_in_n_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_head_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>blocks_file_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_threshold_ff_0</source_block_id><sink_block_id>blocks_float_to_char_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0</source_block_id><sink_block_id>blocks_threshold_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_1</source_block_id><sink_block_id>fft_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>logpwrfft_x_0</source_block_id><sink_block_id>blocks_vector_to_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>fft_filter_xxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
